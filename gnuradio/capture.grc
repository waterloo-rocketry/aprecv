options:
  parameters:
    author: rio
    generate_options: no_gui
    id: capture
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32000'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: capture.data
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/rio/code/rocketry/brb_sdr/capture.data
    length: '1800000'
    offset: '134760000'
    repeat: 'False'
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000'
    decim: '12'
    gain: '1'
    samp_rate: '2400000'
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '5'
    type: ccc
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
